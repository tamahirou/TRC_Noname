# Repository tamahirou/TRC_Noname

File README.md:

# TRC2027基板回路図説明書

### 0.これは回路図段階で書いたものです
# 1.メイン基板について
### 1-1.電源ブロック
DCDCコンバーターについて
| 使用モジュール | 元電源電圧 | 変換電源電圧 | 最大電流 |
| :------------ | :-------- | :---------- | :------ |
| LMR38025 | 22.2V~25.2V | 5V | 3A |
| OKL-T/6-W12N-C | 5V | 3.3V | 6A |

電源接続コネクタ : XT90

電源最大許容電流 : 10A それ以上になるとヒューズで切れます

逆接保護 : SBDとヒューズ　逆接時ショート状態になった後ヒューズが切れることにより安全に遮断

## KiCad design TRC2027/TRC2027_CTRL/controller.kicad_pcb

Parts:
A1: RaspberryPi_Pico; RaspberryPi_Pico_Common_Unspecified
D1: R in LED(5V); LED_D5.0mm
D2: R in LED(3.3V); LED_D5.0mm
D3, D5, D7, D9: Blue LED; LED_0603_1608Metric
D4, D6, D8, D10: Green LED; LED_0603_1608Metric
J6: Conn_01x07_Pin; PinHeader_1x07_P2.54mm_Vertical
J8, J9: Conn_01x08_Pin; PinHeader_1x08_P2.54mm_Vertical
J13: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R9, R10, R11, R12, R13, R14, R15, R16: 10; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8: SW_Push; TVGP01G73BB

Connections:
+3.3V: A1.36 (3V3), D2.2 (A), SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2
+5V: A1.39 (VSYS), D1.2 (A), J6.6, J9.7
AUX: A1.11 (GPIO8), J6.5
CE: J8.6
GND: A1.3 (GND), A1.8 (GND), A1.13 (GND), A1.18 (GND), A1.23 (GND), A1.28 (GND), A1.38 (GND), D1.1 (K), D2.1 (K), J6.7, J8.1, J9.8, J13.1, J13.2, J13.3, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2
GP9: A1.12 (GPIO9), R1.1, SW1.1
GP10: A1.14 (GPIO10), R2.1, SW2.1
GP11: A1.15 (GPIO11), R3.1, SW3.1
GP12: A1.16 (GPIO12), R4.1, SW4.1
GP13: A1.17 (GPIO13), R5.1, SW5.1
GP14: A1.19 (GPIO14), R6.1, SW6.1
GP15: A1.20 (GPIO15), R7.1, SW7.1
GP16: A1.21 (GPIO16), R8.1, SW8.1
M0: A1.9 (GPIO6), J6.1
M1: A1.10 (GPIO7), J6.2
unnamed: A1.22 (GPIO17), D3.2 (A)
unnamed: A1.24 (GPIO18), D5.2 (A)
unnamed: A1.25 (GPIO19), D7.2 (A)
unnamed: A1.26 (GPIO20), D9.2 (A)
unnamed: A1.27 (GPIO21), D4.2 (A)
unnamed: A1.29 (GPIO22), D6.2 (A)
unnamed: A1.31 (GPIO26_ADC0), D8.2 (A)
unnamed: A1.32 (GPIO27_ADC1), D10.2 (A)
unnamed: D3.1 (K), R9.1
unnamed: D4.1 (K), R10.1
unnamed: D5.1 (K), R11.1
unnamed: D6.1 (K), R12.1
unnamed: D7.1 (K), R13.1
unnamed: D8.1 (K), R14.1
unnamed: D9.1 (K), R15.1
unnamed: D10.1 (K), R16.1
RX: A1.2 (GPIO1), J6.4
RX1: A1.7 (GPIO5), J9.3
SCL: A1.5 (GPIO3), J9.5
SDA: A1.4 (GPIO2), J9.6
TX: A1.1 (GPIO0), J6.3
TX1: A1.6 (GPIO4), J9.4

Notes on the sheet:
GPS DSELスイッチを0 or 1に
Lora

Board: 2 copper layers, 144.0 x 63.3 mm, 39 parts (34 on the bottom side), 36 nets.

File TRC2027/TRC2027_CTRL/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
A1,RaspberryPi_Pico_Common_Unspecified,1,RaspberryPi_Pico,
D1,LED_D5.0mm,1,R(5V),
"D10, D4, D6, D8",0603,4,Green LED,
D2,LED_D5.0mm,1,R(3.3V),
"D3, D5, D7, D9",0603,4,Blue LED,
J13,PinHeader_1x03_P2.54mm_Vertical,1,Conn_01x03_Pin,
J6,PinHeader_1x07_P2.54mm_Vertical,1,Conn_01x07_Pin,
"J8, J9",PinHeader_1x08_P2.54mm_Vertical,2,Conn_01x08_Pin,
"R1, R2, R3, R4, R5, R6, R7, R8",R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal,8,10k,
"R10, R11, R12, R13, R14, R15, R16, R9",R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal,8,10,
"SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8",TVGP01G73BB,8,SW_Push,

## KiCad design TRC2027/TRC2027main2/TRC2027main2.kicad_pcb

Parts:
A1: RaspberryPi_Pico; RaspberryPi_Pico_Common_Unspecified
C3: 47u; CP_Radial_D5.0mm_P2.00mm
D3, D4, D5, D6, D7, D9, D10, D11, D12, D13: UCLAMP3381P.TFT; UCLAMP3381PTFT; Mouser Part Number 947-UCLAMP3381P.TFT
IC1: MCP23017-E_SP; DIP794W56P254L3486H508Q28N; Manufacturer_Part_Number MCP23017-E/SP; Mouser Part Number 579-MCP23017-E/SP
J6: Conn_01x07_Pin; PinHeader_1x07_P2.54mm_Vertical
J7, J11: BNO055; PinSocket_1x04_P2.54mm_Vertical
J8, J9: Conn_01x08_Pin; PinHeader_1x08_P2.54mm_Vertical
J10: Memory; PinSocket_1x07_P2.54mm_Vertical
J12: Temperature, pressure, and altitude sensor; PinSocket_1x07_P2.54mm_Vertical
J13: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
J14, J15, J16, J17, J18, J21, J24, J25: Conn_01x04_Pin; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J19: Conn_01x12_Pin; PinHeader_1x12_P2.54mm_Vertical
J20: Conn_01x10_Pin; PinHeader_1x10_P2.54mm_Vertical
J30: Conn_01x20_Pin; JST_XH_B20B-XH-A_1x20_P2.50mm_Vertical
R1, R2: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4, R9: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5, R6, R7, R8: 10; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R10: 75; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R11: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
S1: ST12-303FCG; ST12303FCG; Manufacturer_Part_Number ST12-303FCG

Connections:
+3.3V: C3.1, IC1.9 (VDD), IC1.18 (~RESET), J7.4, J10.7, J16.2, J19.3, J30.4, R1.1, R2.1, R10.1, S1.1
+5V: A1.39 (VSYS), J6.6, J9.7, J12.1, J14.1, J15.2, J17.2, J18.2, J19.2, J21.2, J30.5
AIN1: A1.9 (GPIO6), J30.20
AIN2: A1.10 (GPIO7), J30.19
AUX: IC1.5 (GPB4), J6.5
AnFAULT: IC1.1 (GPB0), J30.9
BIN1: A1.11 (GPIO8), J30.18
BIN2: A1.12 (GPIO9), J30.17
BnFAULT: IC1.2 (GPB1), J30.8
CIN1: A1.14 (GPIO10), J30.16
CIN2: A1.15 (GPIO11), J30.15
CS: A1.22 (GPIO17), J10.1
CnFAULT: IC1.3 (GPB2), J30.7
DIN1: A1.26 (GPIO20), J30.14
DIN2: A1.27 (GPIO21), J30.13
DnFAULT: IC1.4 (GPB3), J30.6
GND: A1.3 (GND), A1.8 (GND), A1.13 (GND), A1.18 (GND), A1.23 (GND), A1.28 (GND), A1.33 (AGND), A1.38 (GND), C3.2, D3.2, D4.2, D5.2, D6.2, D7.2, D9.2, D10.2, D11.2, D12.2, D13.2, IC1.10 (VSS), IC1.15 (A0), IC1.16 (A1), IC1.17 (A2), J6.7, J7.3, J8.1, J9.8, J10.5, J11.3, J12.2, J13.1, J13.2, J13.3, J14.4, J15.1, J16.1, J17.1, J18.1, J19.1, J19.6, J20.8, J20.9, J20.10, J21.1, J24.2, J25.2, J30.3, R11.1, S1.MH2
LED1: IC1.21 (GPA0), R4.2
LED2: IC1.22 (GPA1), R5.2
LED3: IC1.23 (GPA2), R6.2
LED4: IC1.24 (GPA3), R9.2
LED5: IC1.25 (GPA4), R8.2
LED6: IC1.26 (GPA5), R7.2
LEDSW: IC1.27 (GPA6), R11.2, S1.3
M0: A1.20 (GPIO15), J6.1
M1: A1.29 (GPIO22), J6.2
MISO: A1.21 (GPIO16), J10.3
MOSI: A1.25 (GPIO19), J10.2
unnamed: J24.1, R4.1
unnamed: J24.3, R5.1
unnamed: J24.4, R6.1
unnamed: J25.1, R9.1
unnamed: J25.3, R8.1
unnamed: J25.4, R7.1
unnamed: R10.2, S1.MH1
PWM: A1.16 (GPIO12), J30.12
PWM2: A1.17 (GPIO13), J30.11
PWM3: A1.19 (GPIO14), J30.10
PWRKEY: IC1.7 (GPB6), J19.5
RESET: IC1.8 (GPB7), J19.4
RST1: IC1.6 (GPB5), J8.6
RX: A1.2 (GPIO1), D7.1, J15.4
RX1: A1.7 (GPIO5), J6.4
RX2: D3.1, J18.4, J19.8, J21.4
SCK: A1.24 (GPIO18), J10.4
SCL: A1.5 (GPIO3), D5.1, D10.1, D13.1, IC1.12 (SCL), J7.1, J9.5, J12.6, J14.3, J16.4, J17.4, R1.2
SDA: A1.4 (GPIO2), D6.1, D11.1, D12.1, IC1.13 (SDA), J7.2, J9.6, J12.7, J14.2, J16.3, J17.3, R2.2
TX: A1.1 (GPIO0), D9.1, J15.3
TX1: A1.6 (GPIO4), J6.3
TX2: D4.1, J18.3, J19.7, J21.3

Notes on the sheet:
Temperature, pressure, and altitude sensor
GPS DSELスイッチを1に
Lora
SW_LED
NFC/Felica
camera
LiDAR
camera2
I2C⇔UART変換
BNO055
FullColer_LED
LTE VINとVIOのジャンパを外す

Board: 2 copper layers, 153.0 x 100.0 mm, 43 parts (0 on the bottom side), 50 nets.

File TRC2027/TRC2027main2/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"_2, ",,2,,
A1,RaspberryPi_Pico_Common_Unspecified,1,RaspberryPi_Pico,
C3,CP_Radial_D5.0mm_P2.00mm,1,47u,
"D10, D11, D12, D13, D3, D4, D5, D6, D7, D9",UCLAMP3381PTFT,10,UCLAMP3381P.TFT,
IC1,DIP794W56P254L3486H508Q28N,1,MCP23017-E_SP,
J10,PinSocket_1x07_P2.54mm_Vertical,1,Memory,
"J11, J7",PinSocket_1x04_P2.54mm_Vertical,2,BNO055,
J12,PinSocket_1x07_P2.54mm_Vertical,1,"Temperature, pressure, and altitude sensor",
J13,PinHeader_1x03_P2.54mm_Vertical,1,Conn_01x03_Pin,
"J14, J15, J16, J17, J18, J21, J24, J25",JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,8,Conn_01x04_Pin,
J19,PinHeader_1x12_P2.54mm_Vertical,1,Conn_01x12_Pin,
J20,PinHeader_1x10_P2.54mm_Vertical,1,Conn_01x10_Pin,
J30,JST_XH_B20B-XH-A_1x20_P2.50mm_Vertical,1,Conn_01x20_Pin,
J6,PinHeader_1x07_P2.54mm_Vertical,1,Conn_01x07_Pin,
"J8, J9",PinHeader_1x08_P2.54mm_Vertical,2,Conn_01x08_Pin,
"R1, R2",R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal,2,4.7k,
R10,R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal,1,75,
R11,R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal,1,10k,
"R4, R9",R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal,2,330,
"R5, R6, R7, R8",R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal,4,10,
S1,ST12303FCG,1,ST12-303FCG,

## KiCad design TRC2027/TRC2027main/TRC2027main_ver2.kicad_pcb

Parts:
C2: 0.1μF; C_0603_1608Metric
C6: 22u; C_0603_1608Metric
C7, C9, C11: 100u; CP_Radial_D8.0mm_P3.50mm
C8: 10u; C_0603_1608Metric
D1: 5V抵抗内蔵; LED_D5.0mm
D2: 3.3V抵抗内蔵; LED_D5.0mm
D8: MBR3045FCT; TO255P480X1000X2050-3P; Manufacturer_Part_Number MBR3045FCT
F2: 3557-15; FUSE_3557-15; PARTREV D
J1: Power_conn(XT90); AMASS_XT90PW-M_1x02_P10.90mm_Horizontal
J2: 電圧計_測定; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J3: 電圧計_電源; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J4, J5, J22, J23: XH_Moter_Output; JST_VH_B2P-VH-B_1x02_P3.96mm_Vertical
J26, J27, J28: Conn_01x03_Pin; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J30: Conn_01x20_Pin; JST_XH_B20B-XH-A_1x20_P2.50mm_Vertical
MD1: OKL-T_6-W12N-C; OKL-T&slash_6-W12N-C-Kai; MOUSER_PART_NUMBER 580-OKL-T/6-W12N-C; MOUSER_DESCRIPTION Non-Isolated DC/DC Converters 12Vin .59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
PS1: MAU102_電圧計用切り離し; MAU101; Manufacturer_Part_Number MAU102
R1: 1.5k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 680; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3: 1.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1: SW_SPST; AMASS_XT90PW-M_1x02_P10.90mm_Horizontal
U1: LM70880Module
U2, U3, U4, U5: DRV8262DDWR; DRV8262DDWRModule
U6, U7, U8, U9, U10: LM70880Module_1

Connections:
5V_A: C9.1, C11.1, J26.2, J27.2, J28.2, U6.4 (VOUT); also elsewhere on the board
12V_A: U2.3 (VM), U7.4 (VOUT)
12V_B: U3.3 (VM), U8.4 (VOUT)
12V_C: U4.3 (VM), U9.4 (VOUT)
12V_D: U5.3 (VM), U10.4 (VOUT)
+3.3V: C7.1, C8.1, D2.2 (A), J30.4, MD1.4 (VOUT), MD1.5 (SENSE), R3.1, U2.9 (VCC), U3.9 (VCC), U4.9 (VCC), U5.9 (VCC)
+5V: C6.1, D1.2 (A), J30.5, MD1.2 (VIN), PS1.1 (+VIN), U1.4 (VOUT)
+5VD: J3.1, PS1.6 (+VOUT)
+24V: C2.1, J2.1, SW1.2 (B), U1.2 (VIN), U6.2 (VIN), U7.2 (VIN), U8.2 (VIN), U9.2 (VIN), U10.2 (VIN)
+BATT: F2.1_1, F2.1_2, J1.2
AIN1: J30.20, U2.7 (IN1)
AIN2: J30.19, U2.6 (IN2)
AOUT1: J4.1, U2.1 (OUT1)
AOUT2: J4.2, U2.2 (OUT2)
AnFAULT: J30.9, U2.5 (nFAULT)
BIN1: J30.18, U3.7 (IN1)
BIN2: J30.17, U3.6 (IN2)
BOUT1: J5.1, U3.1 (OUT1)
BOUT2: J5.2, U3.2 (OUT2)
BnFAULT: J30.8, U3.5 (nFAULT)
CIN1: J30.16, U4.7 (IN1)
CIN2: J30.15, U4.6 (IN2)
COUT1: J23.1, U4.1 (OUT1)
COUT2: J23.2, U4.2 (OUT2)
CnFAULT: J30.7, U4.5 (nFAULT)
DIN1: J30.14, U5.7 (IN1)
DIN2: J30.13, U5.6 (IN2)
DOUT1: J22.1, U5.1 (OUT1)
DOUT2: J22.2, U5.2 (OUT2)
DnFAULT: J30.6, U5.5 (nFAULT)
GND: C2.2, C6.2, C7.2, C8.2, C9.2, C11.2, D1.1 (K), D2.1 (K), D8.1 (A_1), D8.3 (A_2), J1.1, J2.2, J26.1, J27.1, J28.1, J30.3, MD1.3 (1_GROUND), MD1.7 (2_GROUND), PS1.2 (-VIN), R2.2, R3.2, U1.1 (GND), U1.3 (GND), U2.4 (GND), U2.8 (GND), U3.4 (GND), U3.8 (GND), U4.4 (GND), U4.8 (GND), U5.4 (GND), U5.8 (GND), U6.1 (GND), U6.3 (GND), U7.1 (GND), U7.3 (GND), U8.1 (GND), U8.3 (GND), U9.1 (GND), U9.3 (GND), U10.1 (GND), U10.3 (GND); also elsewhere on the board
GND1: J3.2, PS1.4 (-VOUT)
unnamed: D8.2 (K), F2.2_1, F2.2_2, SW1.1 (A)
unnamed: MD1.6 (TRIM), R1.1
unnamed: R1.2, R2.1
PWM: J26.3, J30.12; also elsewhere on the board
PWM2: J27.3, J30.11; also elsewhere on the board
PWM3: J28.3, J30.10

Notes on the sheet:
power
servo
Moter

Board: 4 copper layers, 107.0 x 157.5 mm, 37 parts (0 on the bottom side), 38 nets.

Other parts of the board:
J26_Servo, J27_Servo: Conn_01x03_Pin; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical

Their connections:
5V_A: J26_Servo.2, J27_Servo.2; also elsewhere on the board
GND: J26_Servo.1, J27_Servo.1; also elsewhere on the board
PWM: J26_Servo.3; also elsewhere on the board
PWM2: J27_Servo.3; also elsewhere on the board

File TRC2027/TRC2027main/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C11, C7, C9",CP_Radial_D8.0mm_P3.50mm,3,100u,
C2,0603,1,0.1μF,
C6,0603,1,22u,
C8,0603,1,10u,
D1,LED_D5.0mm,1,5V抵抗内蔵,
D2,LED_D5.0mm,1,3.3V抵抗内蔵,
D8,TO255P480X1000X2050-3P,1,MBR3045FCT,
F2,FUSE_3557-15,1,3557-15,
J1,AMASS_XT90PW-M_1x02_P10.90mm_Horizontal,1,Power_conn(XT90),
J2,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,電圧計_測定,
J22,JST_VH_B2P-VH-B_1x02_P3.96mm_Vertical,1,D_Moter,
J23,JST_VH_B2P-VH-B_1x02_P3.96mm_Vertical,1,XH_Moter_Output,
"J26_SERVO, J27_SERVO",JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical,2,Conn_01x03_Pin,
J28,JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical,1,servo,
J3,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,電圧計_電源,
J30,JST_XH_B20B-XH-A_1x20_P2.50mm_Vertical,1,Conn_01x20_Pin,
J4,JST_VH_B2P-VH-B_1x02_P3.96mm_Vertical,1,A_Moter,
J5,JST_VH_B2P-VH-B_1x02_P3.96mm_Vertical,1,B_Moter,
MD1,OKL-T&slash_6-W12N-C-Kai,1,OKL-T_6-W12N-C,OKL-T/6-W12N-C
PS1,MAU101,1,MAU102_電圧計用切り離し,
R1,R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal,1,1.5k,
R2,R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal,1,680,
R3,R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal,1,1.2k,
SW1,AMASS_XT90PW-M_1x02_P10.90mm_Horizontal,1,SW_SPST,
U1,LM70880Module,1,~,
"U10, U6, U7, U8, U9",LM70880Module_1,5,~,
"U2, U3, U4, U5",DRV8262DDWRModule,4,DRV8262DDWR,

## KiCad design TRC2027/USB-PD_board/USB-PD_board.kicad_pcb

Parts:
C1: 1u; C_0603_1608Metric
D1: LED; LED_0603_1608Metric
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_XKB_U262-16XN-4BVC11
J2: amass_xt30; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
J3: xh; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
R1: 1k; R_0603_1608Metric
R2, R3, R4, R5: 10k; R_0603_1608Metric
R6: 10; R_0603_1608Metric
SW1: SW_DIP_x03; SW_DIP_SPSTx03_Slide_OTAX_KSD32_W5.08mm_P2.54mm
U1: CH224K; SSOP-10-1EP_3.9x4.9mm_P1mm_EP2.1x3.3mm

Connections:
CC1: J1.A5 (CC1), U1.7 (CC1)
CC2: J1.B5 (CC2), U1.6 (CC2)
D+: J1.A6 (D+), J1.B6 (D+), U1.4 (DP)
D-: J1.A7 (D-), J1.B7 (D-), U1.5 (DM)
GND: C1.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.1, J3.1, SW1.4, SW1.5, SW1.6, U1.11 (GND)
unnamed: D1.2 (A), R6.2
unnamed: D1.1 (K), U1.10 (PG)
unnamed: R3.2, SW1.1, U1.9 (CFG1)
unnamed: R4.2, SW1.2, U1.2 (CFG2)
unnamed: R5.2, SW1.3, U1.3 (CFG3)
unnamed: R2.2, U1.8 (VBUS)
VBUS: J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J2.2, J3.2, R1.1, R2.1
VDD: C1.1, R1.2, R3.1, R4.1, R5.1, R6.1, U1.1 (VDD)

Board: 4 copper layers, 10.9 x 48.3 mm, 13 parts (0 on the bottom side), 13 nets.

File TRC2027/USB-PD_board/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,0603,1,1u,
D1,0603,1,LED,
J1,USB_C_Receptacle_XKB_U262-16XN-4BVC11,1,USB_C_Receptacle_USB2.0_16P,
J2,AMASS_XT30PW-F_1x02_P2.50mm_Horizontal,1,amass_xt30,
J3,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,xh,
R1,0603,1,1k,
"R2, R3, R4, R5",0603,4,10k,
R6,0603,1,10,
SW1,SW_DIP_SPSTx03_Slide_OTAX_KSD32_W5.08mm_P2.54mm,1,SW_DIP_x03,
U1,SSOP-10-1EP_3.9x4.9mm_P1mm_EP2.1x3.3mm,1,CH224K,
