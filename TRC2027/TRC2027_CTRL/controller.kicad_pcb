# Repository tamahirou/TRC_Noname (continued)

## KiCad design TRC2027/LM70880Module_12V/LM70880Module_12V/LM70880Module_12V.kicad_pcb

Parts:
C1: 15u; CP_Radial_D10.0mm_P5.00mm
C2: 0.1u; C_0603_1608Metric
C3: 4.7u; C_0805_2012Metric
C4: 3.3n; C_0603_1608Metric
C5: 22p; C_0603_1608Metric
C6: 47n; C_0603_1608Metric
C8: 1u; C_0603_1608Metric
C9, C10, C11, C12, C13, C14: 10u; C_0805_2012Metric
J1, J2: Conn_01x02_Pin; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
L1: 8.2u; L_Wuerth_WE-PD-Typ-LS_Handsoldering
R1: 237k; R_0805_2012Metric
R2: 19.6k; R_0805_2012Metric
R3: 49.9k; R_0805_2012Metric
R4: 9.53k; R_0805_2012Metric
R5: 29.4k; R_0603_1608Metric
R6: 54.9k; R_0603_1608Metric
R7: 1; R_0805_2012Metric
R8: 5m; R_1206_3216Metric
U1: LM70880RRXR; RRX0029B-MFG

Connections:
+12V: C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, J2.2, R8.2, U1.6 (BIAS), U1.12 (VOUT)
+24V: C1.1, C2.1, J1.2, R1.1, U1.1 (VIN4), U1.2 (VIN5), U1.3 (VIN6), U1.27 (VIN1), U1.28 (VIN2), U1.29 (VIN3)
GND: C1.2, C2.2, C3.2, C4.1, C5.1, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, J1.1, J2.1, R2.1, R5.1, R6.1, U1.17 (AGND), U1.23 (PGND1), U1.24 (PGND2), U1.25 (PGND3), U1.26 (PGND4), U1.30 (PGND)
unnamed: C4.2, R4.1
unnamed: C6.2, R7.2
unnamed: C6.1, U1.4 (CBOOT)
unnamed: R5.2, U1.13 (CONFIG)
unnamed: R1.2, R2.2, U1.9 (EN_UVLO)
unnamed: C5.2, R4.2, U1.15 (EXTCOMP)
unnamed: R3.2, U1.16 (FB)
unnamed: L1.2, R8.1, U1.11 (ISNS+)
unnamed: R3.1, U1.8 (PFM_SYNCIN), U1.18 (VDDA)
unnamed: R6.2, U1.14 (RT)
unnamed: L1.1, R7.1, U1.5 (SW4), U1.20 (SW1), U1.21 (SW2), U1.22 (SW3)
unnamed: C3.1, U1.19 (VCC)

Board: 4 copper layers, 29.9 x 29.0 mm, 25 parts (0 on the bottom side), 15 nets.

File TRC2027/LM70880Module_12V/LM70880Module_12V/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,CP_Radial_D10.0mm_P5.00mm,1,15u,
"C10, C11, C12, C13, C14, C9",0805,6,10u,
C2,0603,1,0.1u,
C3,0805,1,4.7u,
C4,0603,1,3.3n,
C5,0603,1,22p,
C6,0603,1,47n,
C8,0603,1,1u,
"J1, J2",AMASS_XT30PW-F_1x02_P2.50mm_Horizontal,2,Conn_01x02_Pin,
L1,L_Wuerth_WE-PD-Typ-LS_Handsoldering,1,8.2u,
R1,0805,1,237k,
R2,0805,1,19.6k,
R3,0805,1,49.9k,
R4,0805,1,9.53k,
R5,0603,1,29.4k,
R6,0603,1,54.9k,
R7,0805,1,1,
R8,1206,1,5m,
U1,RRX0029B-MFG,1,LM70880RRXR,

## KiCad design TRC2027/DRV8262DDWModule/DRV8262DDWModule.kicad_pcb

Parts:
C1: 1u; C_0603_1608Metric
C2: 0.01u; C_0603_1608Metric
C3: 470u; CP_Radial_D10.0mm_P5.00mm
C4: 0.1u; C_0603_1608Metric
D1: LED; LED_D5.0mm
J1, J2: XT30; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
J3: Conn_01x05_Pin; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
R1: 10k; R_1206_3216Metric
R2: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: DRV8262DDWR; HTSSOP44-DDW_TEX

Connections:
/IN1: J3.3, U1.41 (IN1/NFAULT)
/IN2: J3.2, U1.40 (IN2/OCPM)
/VCP: C1.1, U1.1 (VCP/GND)
/VM: C1.2, C2.1, C3.1, J1.2, R2.1, U1.2 (VM), U1.11 (VM), U1.12 (VM), U1.21 (VM)
DVDD: U1.24 (DVDD/CPL), U1.27 (OCPM/IN2), U1.28 (MODE1/RSVD), U1.29 (MODE2/RSVD), U1.33 (VREF), U1.34 (VREF)
GND: C2.2, C3.2, D1.1 (K), J1.1, J3.4, U1.3 (PGND), U1.10 (PGND), U1.13 (PGND), U1.20 (PGND), U1.22 (GND/VCP), U1.23 (GND/CPH), U1.35 (TOFF/RSVD), U1.37 (DECAY/IPROPI), U1.EPAD
unnamed: D1.2 (A), R2.2
unnamed: C4.1, U1.44 (CPH/GND)
unnamed: C4.2, U1.43 (CPL/DVDD)
unnamed: U1.30 (IPROPI/DECAY), U1.31 (IPROPI/RSVD)
OUT1: J2.2, U1.4 (OUT1), U1.5 (OUT1), U1.6 (OUT1), U1.17 (OUT1), U1.18 (OUT1), U1.19 (OUT1)
OUT2: J2.1, U1.7 (OUT2), U1.8 (OUT2), U1.9 (OUT2), U1.14 (OUT2), U1.15 (OUT2), U1.16 (OUT2)
VCC: J3.5, R1.2, U1.25 (VCC/NSLEEP), U1.42 (NSLEEP/VCC)
nFAULT: J3.1, R1.1, U1.26 (NFAULT/IN1)

Notes on the sheet:
コネクト

Board: 2 copper layers, 45.0 x 31.5 mm, 11 parts (0 on the bottom side), 14 nets.

## KiCad design TRC2027/R_Sokutei/R_Sokutei.kicad_pcb

Parts:
A1: RaspberryPi_Pico; RaspberryPi_Pico_Common_Unspecified
BT1, BT2, BT3: Battery; BatteryHolder_Keystone_2460_1xAA
C1: 0.1u; C_0603_1608Metric
J1: Conn_02x05_A; PinHeader_2x05_P2.54mm_Vertical
J2: Conn_02x05_B; PinHeader_2x05_P2.54mm_Vertical
J15: ディスプレイ; PinSocket_1x04_P2.54mm_Vertical
Q1, Q2, Q3, Q4: BSS138; SOT-23
R1, R3: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: LM358; DIP-8_W7.62mm

Connections:
+3.3V: A1.36 (3V3), C1.1, J15.3, R2.1, R3.1, R4.1, R5.1
+BATT: A1.39 (VSYS), BT1.1 (+)
ADC0: A1.31 (GPIO26_ADC0), R1.2
GND: A1.3 (GND), A1.8 (GND), A1.13 (GND), A1.18 (GND), A1.23 (GND), A1.28 (GND), A1.33 (AGND), A1.38 (GND), BT3.2 (-), C1.2, J2.1, J2.2, J2.3, J2.4, J2.5, J2.6, J2.7, J2.8, J2.9, J2.10, J15.4, U1.2 (-)
GP2: A1.4 (GPIO2), Q1.2 (G)
GP3: A1.5 (GPIO3), Q2.2 (G)
GP4: A1.6 (GPIO4), Q3.2 (G)
GP5: A1.7 (GPIO5), Q4.2 (G)
unnamed: BT1.2 (-), BT2.1 (+)
unnamed: BT2.2 (-), BT3.1 (+)
unnamed: J1.1, J1.2, J1.3, J1.4, J1.5, J1.6, J1.7, J1.8, J1.9, J1.10, Q1.3 (S), Q2.3 (S), Q3.3 (S), Q4.3 (S), U1.3 (+)
unnamed: Q1.1 (D), R2.2
unnamed: Q2.1 (D), R3.2
unnamed: Q3.1 (D), R4.2
unnamed: Q4.1 (D), R5.2
unnamed: R1.1, U1.1
SCL: A1.2 (GPIO1), J15.2
SDA: A1.1 (GPIO0), J15.1

Board: 2 copper layers, 18 parts (0 on the bottom side), 18 nets, no tracks yet.

## KiCad design TRC2027/DRV8256PModule/DRV8256PModule.kicad_pcb

Parts:
C1: 0.22u; C_0603_1608Metric
C2, C3: 0.01u; C_0603_1608Metric
C4: 100u; CP_Radial_D8.0mm_P3.50mm
C5: 0.022u; C_0603_1608Metric
C6: 0.47u; C_0603_1608Metric
J1, J2: XT30; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
J3: pinhe; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
R1, R2: 10k; R_1206_3216Metric
U1: DRV8256ERGER; VQFN_6PRGER_TEX

Connections:
DVDD: C6.1, J3.4, R1.1, R2.2, U1.10 (DVDD), U1.12 (VREF), U1.13 (VREF), U1.16 (DECAY)
GND: C2.2, C3.2, C4.2, C5.2, C6.2, J1.1, U1.2 (PGND), U1.7 (PGND), U1.9 (GND), U1.14 (TOFF), U1.22 (CPL), U1.25 (THERMAL_PAD)
IN1: J3.3, U1.20 (IN1)
IN2: J3.2, U1.19 (IN2)
unnamed: C5.1, U1.23 (CPH)
unnamed: C1.2, U1.24 (VCP)
unnamed: R1.2, U1.21 (nSLEEP)
OUT1: J2.2, U1.3 (OUT1), U1.6 (OUT1)
OUT2: J2.1, U1.4 (OUT2), U1.5 (OUT2)
VM: C1.1, C2.1, C3.1, C4.1, J1.2, U1.1 (VM), U1.8 (VM)
nFAULT: J3.1, R2.1, U1.11 (nFAULT)

Notes on the sheet:
↓ロジック電圧入力ピン
↑保護履歴ピン
外部コネクタ

Board: 2 copper layers, 25.6 x 38.5 mm, 12 parts (0 on the bottom side), 11 nets.

## Code that names these connections

File program/Aircraft.py:

"""
【機体側】受信プログラム
Wio-E5: UART1 / GP4(TX), GP5(RX)
モーターA: AIN1=GP0, AIN2=GP1
モーターB: BIN1=GP2, BIN2=GP3
"""
from machine import UART, Pin
import time

# ===== LoRa UART =====
uart = UART(1, 9600)
uart.init(9600, bits=8, parity=None, stop=1, tx=Pin(4), rx=Pin(5))

# ===== DCモーター =====
AIN1 = Pin(0, Pin.OUT)
AIN2 = Pin(1, Pin.OUT)
BIN1 = Pin(2, Pin.OUT)
BIN2 = Pin(3, Pin.OUT)

def forward():
    AIN1.value(0); AIN2.value(1)
    BIN1.value(1); BIN2.value(0)

def backward():
    AIN1.value(1); AIN2.value(0)
    BIN1.value(0); BIN2.value(1)

def turn_left():
    AIN1.value(1); AIN2.value(0)
    BIN1.value(1); BIN2.value(0)

def turn_right():
    AIN1.value(0); AIN2.value(1)
    BIN1.value(0); BIN2.value(1)

def all_stop():
    AIN1.value(0); AIN2.value(0)
    BIN1.value(0); BIN2.value(0)

ACTIONS = {
    "M:FWD": (forward,    "前進"),
    "M:BCK": (backward,   "後進"),
    "M:LFT": (turn_left,  "左旋回"),
    "M:RGT": (turn_right, "右旋回"),
    "M:STP": (all_stop,   "停止"),
}

def send_command(cmd, wait_time=1):
    uart.write(cmd + "\r\n")
    time.sleep(wait_time)
    response = ""
    while uart.any():
        data = uart.read()
        try:
            response += data.decode()
        except:
            pass
    print("CMD: " + cmd + " -> " + response.strip())
    return response.strip()

def restart_rx():
    uart.write("AT+TEST=RXLRPKT\r\n")
    time.sleep(0.3)
    while uart.any():
        uart.read()

def check_received():
    if uart.any():
        data = uart.read()
        try:
            response = data.decode()
        except:
            return None
        if "+TEST: RX" in response:
            try:
                start = response.find('"')
                if start != -1:
                    start += 1
                    end = response.find('"', start)
                    if end != -1:
                        return bytes.fromhex(response[start:end]).decode()
            except Exception as e:
                print("解析エラー: " + str(e))
    return None

# ===== 初期化 =====
print("=== 機体側起動 ===")
all_stop()
time.sleep(1)
send_command("AT")
send_command("AT+MODE=TEST")
send_command("AT+TEST=RFCFG,923,7,0,1,8,14", 0.5)
send_command("AT+TEST=RXLRPKT")
print("=== 受信待機中 ===\n")

# ===== メインループ =====
rx_count = 0
last_rx_time = time.time()
TIMEOUT_SEC = 2  # ★ 2秒に短縮（送信間隔0.5秒に合わせて）

while True:
    try:
        msg = check_received()

        if msg:
            msg = msg.strip()
            last_rx_time = time.time()
            rx_count += 1
            if msg in ACTIONS:
                action, label = ACTIONS[msg]
                action()
                print("[RX#" + str(rx_count) + "] " + label)
            else:
                print("[RX#" + str(rx_count) + "] 不明: " + msg)
            restart_rx()

        # タイムアウト → 自動停止
        if time.time() - last_rx_time > TIMEOUT_SEC:
            all_stop()
            last_rx_time = time.time()
            print("[タイムアウト] 停止")

        time.sleep(0.05)

    except KeyboardInterrupt:
        all_stop()
        print("\n終了")
        break
    except Exception as e:
        print("エラー: " + str(e))
        all_stop()
        import sys
        sys.print_exception(e)

## Commit log (part)

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2026-01-04 回路図変えたよ
2026-01-14 基板をめちゃめちゃ修正しました
2026-01-15 Create プログラム
2026-01-23 回路図系の更新
2026-01-28 いろいろと変更
2026-01-29 変更しちゃった
2026-02-06 LIdarテストプログラム
2026-02-06 GPSのテストプログラム
2026-02-07 kairozukousin
2026-02-07 add GPS_henkan
2026-02-10 プルダウン抵抗とフットプリントを修正しました
2026-03-12 回路図修正
2026-03-13 ラジコン
2026-03-18 ラジコン操作のプログラム
2026-03-19 LoRaだけの通信プログラム
2026-03-20 機体側のPWM制御のラジコン
2026-04-01 いろいろ追加
2026-04-01 add LTE_Module
2026-04-01 moromoro
2026-04-01 add DataSheet
2026-04-04 change DataSheet
2026-04-04 deleted: DataSheet_Ver.1.pdf
2026-04-18 add TRC2027main/SW_LED
2026-04-18 deleted: TRC2027/TRC2027_con/.history
2026-04-26 new file: TRC2027/R_Sokutei/R_Sokutei-backups/R_Sokutei-2026-04-18_181141.zip
2026-06-23 Add positions.csv file with component placements and orientations
2026-06-23 delete
