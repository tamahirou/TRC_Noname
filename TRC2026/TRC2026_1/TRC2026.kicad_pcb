# Repository tamahirou/TRC_Noname

## KiCad design TRC2026/TRC2026_1/TRC2026.kicad_pcb

Board: 2 copper layers, 79.0 x 180.0 mm, 43 parts (0 on the bottom side), 52 nets.

Parts:
A1: RaspberryPi_Pico; RaspberryPi_Pico_Common_Unspecified
A2: RaspberryPi_Pico_W; RaspberryPi_PicoW_Common_THT
C1, C6, C7, C8: 100μF; CP_Radial_D8.0mm_P3.50mm
C3: 0.1μF; C_0603_1608Metric
D9, D10, D11, D12, D13, D14: UCLAMP3381P.TFT; SOD2513X114N
D15: 5V抵抗内蔵LED; LED_D5.0mm
J1, J15, J16, J17: 2F接続; PinHeader_1x04_P2.54mm_Vertical
J2: Aモータードライバー; PinHeader_1x08_P2.54mm_Vertical
J3: Aモーター出力; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J4: Bモータードライバー; PinHeader_1x08_P2.54mm_Vertical
J5: Bモーター出力; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J6: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
J7: GPS; PinSocket_1x04_P2.54mm_Vertical
J8, J9: Conn_01x08_Pin; PinHeader_1x08_P2.54mm_Vertical
J10: メモリ; PinSocket_1x07_P2.54mm_Vertical
J11: BNO055; PinSocket_1x04_P2.54mm_Vertical
J12: 気温気圧高度センサ; PinSocket_1x07_P2.54mm_Vertical
J13, J14, J18: Conn_01x04_Pin; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J19: サーボ1; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J20: サーボ2; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J21: サーボ3(予備); JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J22: LoRa; PinSocket_1x12_P2.54mm_Vertical
J23: Conn_01x12_Pin; PinSocket_1x12_P2.54mm_Vertical
R1, R4: 1.5Ω; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2, R3, R5, R6: 0.1Ω; R_1210_3225Metric

Connections:
2_GP16: A2.21 (GPIO16), J17.3
+3.3V: A1.36 (3V3), C3.1, J1.3
+5V: A1.39 (VSYS), A2.39 (VSYS), C1.1, C6.1, C7.1, C8.1, D15.2 (A), J1.2, J2.4, J4.4, J7.4, J9.7, J10.7, J12.1, J13.3, J14.3, J18.1, J19.2, J20.2, J21.2, J23.1
+24V: J1.1, J2.5, J4.5, J6.1
AIN1: A1.1 (GPIO0), J2.3
AIN2: A1.2 (GPIO1), J2.2
AOUT1: J2.6, J3.1
AOUT2: J2.8, J3.2
BIN1: A1.4 (GPIO2), J4.3
BIN2: A1.5 (GPIO3), J4.2
BOUT1: J4.6, J5.1
BOUT2: J4.8, J5.2
CS: A1.22 (GPIO17), J10.1
GND: A1.3 (GND), A1.8 (GND), A1.13 (GND), A1.18 (GND), A1.23 (GND), A1.28 (GND), A1.38 (GND), A2.3 (GND), A2.8 (GND), A2.13 (GND), A2.18 (GND), A2.23 (GND), A2.28 (GND), A2.38 (GND), C1.2, C3.2, C6.2, C7.2, C8.2, D9.2, D10.2, D11.2, D12.2, D13.2, D14.2, D15.1 (K), J1.4, J2.1, J4.1, J6.4, J7.3, J8.1, J9.8, J10.5, J11.3, J12.2, J13.4, J14.4, J15.4, J16.4, J17.4, J18.2, J19.1, J20.1, J21.1, J22.12, J23.6, R3.2, R6.2
LED1: A1.10 (GPIO7), J15.1
LED2: A2.9 (GPIO6), J15.2
LED3: A1.26 (GPIO20), J15.3
LED4: A2.10 (GPIO7), J16.1
LED5: A1.27 (GPIO21), J16.2
LED6: A2.11 (GPIO8), J16.3
MISO: A1.21 (GPIO16), J10.3
MOSI: A1.25 (GPIO19), J10.2
unnamed: J2.7, R1.1
unnamed: J4.7, R4.1
unnamed: R1.2, R2.2
unnamed: R2.1, R3.1
unnamed: R4.2, R5.2
unnamed: R5.1, R6.1
PWM1: A2.12 (GPIO9), J19.3
PWM2: A2.19 (GPIO14), J20.3
PWM3: A2.20 (GPIO15), J21.3
Pico_RX: A1.20 (GPIO15), A2.4 (GPIO2)
Pico_TX: A1.19 (GPIO14), A2.5 (GPIO3)
RST: A1.9 (GPIO6), J23.5
RST1: A1.29 (GPIO22), J8.7
RX: A1.7 (GPIO5), J22.6
RX1: A1.17 (GPIO13), J9.3
RX2: A2.2 (GPIO1), D10.1, J13.2
RX3: A2.7 (GPIO5), D12.1, J14.2
RX4: A2.17 (GPIO13), D14.1, J18.4
SCK: A1.24 (GPIO18), J10.4
SCL: A1.12 (GPIO9), J7.1
SCL2: A1.15 (GPIO11), J12.6
SCL3: A2.15 (GPIO11), J17.2
SDA: A1.11 (GPIO8), J7.2
SDA2: A1.14 (GPIO10), J12.7
SDA3: A2.14 (GPIO10), J17.1
TX: A1.6 (GPIO4), J22.7
TX1: A1.16 (GPIO12), J9.4
TX2: A2.1 (GPIO0), D9.1, J13.1
TX3: A2.6 (GPIO4), D11.1, J14.1
TX4: A2.16 (GPIO12), D13.1, J18.3

## KiCad design TRC2026/TRC2026_2/TRC2026_2.kicad_pcb

Board: 2 copper layers, 79.0 x 180.0 mm, 32 parts (0 on the bottom side), 21 nets.

Parts:
C1: 470μF; CAPPRD500W65D1000H1300
C2, C5: 0.1μF; C_0603_1608Metric
C4: 100μF; CP_Radial_D8.0mm_P3.50mm
D1: 5V抵抗内蔵LED; LED_D5.0mm
D2, D3, D4, D5, D6, D7: LED; LED_D5.0mm
D8: MBR3045FCT; TO255P480X1000X2050-3P
F2: 3557-15; FUSE_3557-15
J1: Conn_01x02_Pin; AMASS_XT90PW-M_1x02_P10.90mm_Horizontal
J2, J3, J4, J5, J6: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
J15: Conn_01x04_Pin; PinSocket_1x04_P2.54mm_Vertical
J16: デジタル電圧計(測定); JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J17: デジタル電圧計(電力供給); JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
R7, R8: 470Ω; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R9, R10, R11, R12: 10Ω; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R13: 0.33Ω(熱くなります。基板取り付け時は地面から離しましょう); R_Axial_DIN0516_L15.5mm_D5.0mm_P20.32mm_Horizontal
SW1: SW_SPST; AMASS_XT90PW-M_1x02_P10.90mm_Horizontal
SW2: SW_SPDT; 3MS1J102M2QES
U1: DCDC; LMR

Connections:
2_GP16: J5.3, SW2.2 (B)
+5V: C1.1, D1.2 (A), J2.2, J6.2, J6.3, J15.3, J17.2, U1.14 (VOUT), U1.15 (VOUT), U1.16 (VOUT)
+24V: C2.1, J2.1, J6.1, J16.2, R13.1, SW1.2 (B)
GND: C1.2, C2.2, C4.2, C5.2, D1.1 (K), D8.1 (A_1), D8.3 (A_2), J1.2, J2.4, J3.4, J4.4, J5.4, J6.4, J15.4, J16.1, J17.1, R7.1, R8.1, R9.2, R10.2, R11.2, R12.2, SW2.3 (C), U1.1 (GND), U1.2 (GND), U1.10 (GND), U1.11 (GND), U1.12 (GND), U1.13 (GND)
LED1: D6.2 (A), J3.1
LED2: D5.2 (A), J3.2
LED3: D4.2 (A), J3.3
LED4: D3.2 (A), J4.1
LED5: D7.2 (A), J4.2
LED6: D2.2 (A), J4.3
unnamed: D2.1 (K), R12.1
unnamed: D3.1 (K), R10.1
unnamed: D4.1 (K), R9.1
unnamed: D5.1 (K), R8.2
unnamed: D6.1 (K), R7.2
unnamed: D7.1 (K), R11.1
unnamed: D8.2 (K), F2.2_1, F2.2_2, SW1.1 (A)
unnamed: F2.1_1, F2.1_2, J1.1
unnamed: C4.1, C5.1, R13.2, U1.6 (EN), U1.7 (VIN), U1.8 (VIN), U1.9 (VIN)
SCL3: J5.2, J15.2
SDA3: J5.1, J15.1

## KiCad design TRC2026_Input/TRC2026_Input/TRC2026_Input.kicad_pcb

Board: 2 copper layers, 144.0 x 63.3 mm, 12 parts (0 on the bottom side), 21 nets.

Parts:
A1: RaspberryPi_Pico_W; RaspberryPi_Pico_Common_Unspecified
C1, C6: 0.1μF; C_0603_1608Metric
C2, C4, C5: 100μF; CP_Radial_D8.0mm_P3.50mm
J3, J4, J5, J6: 2F接続; PinHeader_1x05_P2.54mm_Vertical
J22: LoRa; PinSocket_1x12_P2.54mm_Vertical
J23: Conn_01x12_Pin; PinSocket_1x12_P2.54mm_Vertical

Connections:
2_GP16: A1.19 (GPIO14), J4.4
+3.3V: A1.36 (3V3), C2.1, C6.1, J3.2
+5V: A1.40 (VBUS), C1.1, C4.1, C5.1, J3.1, J23.1
ADC0: A1.31 (GPIO26_ADC0), J4.1
ADC1: A1.32 (GPIO27_ADC1), J4.2
ADC2: A1.34 (GPIO28_ADC2), J4.3
GND: A1.3 (GND), A1.8 (GND), A1.13 (GND), A1.18 (GND), A1.23 (GND), A1.28 (GND), A1.33 (AGND), A1.38 (GND), C1.2, C2.2, C4.2, C5.2, C6.2, J3.5, J6.5, J22.12, J23.6
GP2: A1.4 (GPIO2), J6.1
GP3: A1.5 (GPIO3), J6.2
GP4: A1.6 (GPIO4), J6.3
GP5: A1.7 (GPIO5), J6.4
LED1: A1.11 (GPIO8), J4.5
LED2: A1.12 (GPIO9), J5.5
LED3: A1.14 (GPIO10), J5.4
LED4: A1.15 (GPIO11), J5.3
LED5: A1.16 (GPIO12), J5.2
LED6: A1.17 (GPIO13), J5.1
RX: A1.2 (GPIO1), J22.6
SCL3: A1.10 (GPIO7), J3.4
SDA3: A1.9 (GPIO6), J3.3
TX: A1.1 (GPIO0), J22.7

File TRC2026_Input/TRC2026_Input/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
A1,RaspberryPi_Pico_Common_Unspecified,1,RaspberryPi_Pico_W,
"C1, C6",0603,2,0.1μF,
"C2, C4, C5",CP_Radial_D8.0mm_P3.50mm,3,100μF,
J22,PinSocket_1x12_P2.54mm_Vertical,1,LoRa,
J23,PinSocket_1x12_P2.54mm_Vertical,1,Conn_01x12_Pin,
"J3, J4, J5, J6",PinHeader_1x05_P2.54mm_Vertical,4,2F接続,

## KiCad design TRC2026_Input2/TRC2026_Input2.kicad_pcb

Parts:
C3: 0.1μF; C_0603_1608Metric
D2, D3, D4, D5, D6, D7: LED; LED_D5.0mm
D15: 5V抵抗内蔵LED; LED_D5.0mm
J1, J2: Conn_01x06_Pin; PinHeader_1x06_P2.54mm_Vertical
J3, J4, J5, J6: Conn_01x05_Pin; PinHeader_1x05_P2.54mm_Vertical
R1, R2, R3, R4: 3.3k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R7, R8: 470Ω; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R9, R10, R11, R12: 10Ω; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1, SW2, SW3, SW4: SW_Push; TVGP01G73BB
SW5: SW_SPDT; 3MS1J102M2QES

Connections:
2_GP16: J4.4, SW5.2 (B)
+3.3V: C3.1, J1.2, J3.2, SW1.1, SW2.1, SW3.1, SW4.1
+5V: D15.2 (A), J3.1
ADC0: J1.3, J4.1
ADC1: J1.4, J4.2
ADC2: J1.5, J4.3
GND: C3.2, D15.1 (K), J1.1, J1.6, J3.5, J6.5, R1.1, R2.2, R3.2, R4.1, R7.1, R8.1, R9.2, R10.2, R11.2, R12.2, SW5.3 (C); also elsewhere on the board
GP2: J6.1, R1.2, SW1.2; also elsewhere on the board
GP3: J6.2, R4.2, SW2.2
GP4: J6.3, R2.1, SW3.2
GP5: J6.4, R3.1, SW4.2
LED1: D6.2 (A), J4.5
LED2: D5.2 (A), J5.5
LED3: D4.2 (A), J5.4
LED4: D3.2 (A), J5.3
LED5: D7.2 (A), J5.2
LED6: D2.2 (A), J5.1
unnamed: D2.1 (K), R12.1
unnamed: D3.1 (K), R10.1
unnamed: D4.1 (K), R9.1
unnamed: D5.1 (K), R8.2
unnamed: D6.1 (K), R7.2
unnamed: D7.1 (K), R11.1
SCL3: J3.4
SDA3: J3.3

Notes on the sheet:
picoの内蔵プルアップ抵抗を入れること
電源チェック
ジョイスティック
タクトスイッチ
状態表示LED

Board: 2 copper layers, 144.0 x 63.3 mm, 29 parts (0 on the bottom side), 23 nets.

Other parts of the board:
10k: 3.3k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal

Their connections:
GND: 10k.1; also elsewhere on the board
GP2: 10k.2; also elsewhere on the board
